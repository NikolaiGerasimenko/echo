# Keil uVision project echo.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F303VCTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: echo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\User;.\CMSIS\Device;.\CMSIS\Include;.\CMSIS;.\CMSIS\Device\ST\STM32F30x\Include;.\CMSIS\Device\ST\STM32F30x\Source
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group Startup
    ./Startup/: startup_stm32f30x.s
  group CMSIS
    ./CMSIS/Device/ST/STM32F30x/Source/Templates/: system_stm32f30x.c
    ./CMSIS/Device/ST/STM32F30x/Include/: stm32f30x.h system_stm32f30x.h
  group User
    ./User/: main.c
